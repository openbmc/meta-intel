FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append = " file://0001-Should-patch-to-config.json-file-but-not-override-by.patch "

